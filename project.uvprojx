# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, STM32H750xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;board;board\CubeMX_Config\Core\Inc;board\port;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\finsh;.;..\..\..\include;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;packages\nimble;packages\nimble\nimble\include;packages\nimble\nimble\host\include;packages\nimble\nimble\host\src;packages\nimble\nimble\host\services\ans\include;packages\nimble\nimble\host\services\bas\include;packages\nimble\nimble\host\services\bleuart\include;packages\nimble\nimble\host\services\gap\include;packages\nimble\nimble\host\services\gatt\include;packages\nimble\nimble\host\services\ias\include;packages\nimble\nimble\host\services\lls\include;packages\nimble\nimble\host\services\tps\include;packages\nimble\nimble\host\store\ram\include;packages\nimble\nimble\host\util\include;packages\nimble\nimble\transport\include;packages\nimble\nimble\transport\common\hci_h4\include;packages\nimble\porting\npl\rtthread\include;packages\nimble\porting\nimble\include;packages\nimble\ext\tinycrypt\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/touch/: touch.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_sdram.c drv_spi.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group nimble
    packages/nimble/nimble/host/src/: ble_l2cap.c ble_att_svr.c ble_gap.c ble_sm.c ble_hs.c ble_gatts_lcl.c ble_store_util.c ble_hs_conn.c ble_hs_hci_util.c ble_hs_log.c ble_att_clt.c ble_l2cap_coc.c ble_sm_alg.c ble_sm_cmd.c ble_hs_hci_evt.c ble_store.c ble_l2cap_sig_cmd.c ble_att_cmd.c ble_sm_sc.c ble_hs_stop.c ble_hs_cfg.c ble_gattc.c ble_hs_mbuf.c ble_hs_hci.c ble_sm_lgcy.c ble_hs_hci_cmd.c ble_uuid.c ble_hs_flow.c ble_hs_startup.c ble_hs_atomic.c ble_att.c ble_eddystone.c ble_hs_misc.c ble_hs_pvcy.c ble_hs_mqueue.c ble_hs_adv.c ble_hs_periodic_sync.c ble_ibeacon.c ble_l2cap_sig.c ble_gatts.c ble_hs_id.c
    packages/nimble/porting/npl/rtthread/src/: nimble_port_rtthread.c npl_shell.c npl_os_rtthread.c
    packages/nimble/nimble/host/services/ias/src/: ble_svc_ias.c
    packages/nimble/nimble/host/services/ans/src/: ble_svc_ans.c
    packages/nimble/nimble/host/services/gatt/src/: ble_svc_gatt.c
    packages/nimble/porting/nimble/src/: endian.c nimble_port.c mem.c os_mbuf.c os_msys_init.c os_mempool.c
    packages/nimble/nimble/transport/src/: transport.c monitor.c
    packages/nimble/nimble/transport/rtthread/src/: ble_hci_rtthread_uart.c
    packages/nimble/nimble/host/services/lls/src/: ble_svc_lls.c
    packages/nimble/apps/ibeacon/src/: ibeacon.c
    packages/nimble/nimble/host/util/src/: addr.c
    packages/nimble/ext/tinycrypt/src/: cmac_mode.c aes_encrypt.c ecc_dh.c aes_decrypt.c ecc.c utils.c
    packages/nimble/nimble/host/store/ram/src/: ble_store_ram.c
    packages/nimble/nimble/host/services/tps/src/: ble_svc_tps.c
    packages/nimble/nimble/transport/common/hci_h4/src/: hci_h4.c
    packages/nimble/nimble/host/services/bas/src/: ble_svc_bas.c
    packages/nimble/nimble/host/services/gap/src/: ble_svc_gap.c
